Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: \\192.168.0.1\Engenharia\PRODUTOS\SERIE CAM\CAM-W16\IFC\BOMBA CAM-W16 3 CV T 220_380V INC FLG IR3.IFC
Time: 2026-06-05T18:31:47+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
